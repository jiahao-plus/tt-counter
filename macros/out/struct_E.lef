VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
MACRO research_fiducial
  CLASS BLOCK ;
  ORIGIN 3.000 3.000 ;
  SIZE 4.000 BY 4.000 ;
  SYMMETRY X Y ;
END research_fiducial
END LIBRARY
